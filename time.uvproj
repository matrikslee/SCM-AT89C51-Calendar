# Keil uVision project time.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: time +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: main.c time.c pit.c lcd.c key.c delay.c
